# Keil uVision project LPChost.uvproj, settings and files
target LPChost (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPChost +hex
  AfterMake: fromelf --bin --output=.\obj\LPChost.bin .\obj\LPChost.axf
  c flags: Optim=1 wLevel=1
  c define: UART1REC UART0DBG
  c include: ..\App;..\xlib\include;..\GLDcore\include;..\LPChost\include;..\GLDbootloader\include
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x27fff
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group CMSIS
    ./Source/CMSIS/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
    ./Source/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Source/CMSIS/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group APP
    ../App/: CyclesSync.c main.c Parameters.c
  group core
    ../GLDcore/source/: command.c command_handlers.c cplc.c dither.c exchange.c gld.c global.c hfo.c sync.c thermo.c ignit.c ring_buffer.c sip.c math_dsp.c
  group hardware
    ../LPChost/source/: memory.c IAP.c hardware.c pwm.c spi.c uart.c qei.c dac.c ltc1622.c i2c.c
